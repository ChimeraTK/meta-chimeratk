SRC_URI = " \
        gitsm://gitlab.com/tango-controls/cppTango.git;protocol=https;branch=main \
        "
