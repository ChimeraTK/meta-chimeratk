LICENSE="BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e0510e6ecbcdcb87e3cf13147f37f166"


SRC_URI[md5sum] = "77c296962ee94aae423170cb0166ad3b"
SEC_URI[cha256dum] = "af149d672da9493fa37334a1cc68f7b80c3e6cb9fd99b9e426c447db5c650bf0"

inherit pypi setuptools3
